# Keil uVision project my-tramsplant.uvprojx, settings and files
target my-tramsplant (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: my-tramsplant +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../ModuleDrivers;../mqtt/mqtt;../mqtt/platform/FreeRTOS;../mqtt/network;../mqtt/common;../mqtt;../mqtt/mqttclient;../mqtt/network/mbedtls/include;../mqtt/common/PLOOC;../mqtt/at;../mqtt/hal
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c sdio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_sram.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_sd.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group MoudleDrivers
    ../ModuleDrivers/: driver_usart.c ring_buffer.c
    ../ModuleDrivers/KEY/: key.c
    ../ModuleDrivers/LED/: led.c
    ../ModuleDrivers/LCD/: lcd.c
    ../ModuleDrivers/SRAM/: sram.c
  group common
    ../mqtt/common/: mqtt_list.c random.c
  group mqtt
    ../mqtt/mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group mqttclient
    ../mqtt/mqttclient/: mqttclient.c
  group network
    ../mqtt/network/: nettype_tcp.c network.c
  group platform
    ../mqtt/platform/FreeRTOS/: platform_memory.c platform_mutex.c platform_net_socket.c platform_thread.c platform_timer.c
    ../mqtt/at/: at_commend.c
    ../mqtt/hal/: at_uart_hal.c
  group sys
    ../Middlewares/SYSTEM/delay/: delay.c
    ../Middlewares/SYSTEM/sys/: sys.c
target SD (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: my-tramsplant +hex
  AfterMake: fromelf  --bin -o .\my-tramsplant\@L.bin  .\my-tramsplant\\%L
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../ModuleDrivers;..\mqtt\mqtt;..\mqtt\platform\FreeRTOS;..\mqtt\network;..\mqtt\common;..\mqtt;..\mqtt\mqttclient;..\mqtt\network\mbedtls\include;..\mqtt\common\PLOOC;..\mqtt\at;..\mqtt\hal;..\ModuleDrivers\KEY;..\ModuleDrivers\LCD;..\ModuleDrivers\LED;..\Middlewares\SYSTEM\sys;..\Middlewares\SYSTEM\delay;..\Middlewares\SYSTEM\usart;..\ModuleDrivers\SRAM
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 4.3.0
